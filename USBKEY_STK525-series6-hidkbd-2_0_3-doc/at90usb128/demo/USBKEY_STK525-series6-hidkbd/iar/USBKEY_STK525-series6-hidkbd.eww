<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBKEY_STK525-series6-hidkbd.ewp</path>
  </project>
  <batchBuild/>
</workspace>


